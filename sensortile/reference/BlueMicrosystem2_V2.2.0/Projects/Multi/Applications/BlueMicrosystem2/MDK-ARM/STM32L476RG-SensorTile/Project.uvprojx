# Keil uVision project Project.uvprojx, settings and files
target BlueMicrosystem2_STM32L476RG_SensorTile (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476RG STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: BlueMS2_ST +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,STM32_SENSORTILE
  c misc: --no_conditionalize
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\SensorTile;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsm;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\stc3115;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionFX_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionAR_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionCP_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionGR_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_BlueVoice_Library\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Keil
    ./: startup_stm32l476xx.s
  group User
    ../../Src/: AudioBV_Manager.c HWAdvanceFeatures.c main.c MotionAR_Manager.c MotionCP_Manager.c MotionFX_Manager.c MotionGR_Manager.c OTA.c sensor_service.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Doc
    ../../: readme.txt
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsm/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/stc3115/: STC3115_Driver.c
  group Drivers/BSP/SensorTile
    ../../../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_accelero.c SensorTile_audio_in.c SensorTile_BlueNRG.c SensorTile_gg.c SensorTile_gyro.c SensorTile_humidity.c SensorTile_magneto.c SensorTile_pressure.c SensorTile_temperature.c
  group Drivers/STM32L4xx-Nucleo
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c
  group Middlewares/ST/STM32_BlueNRG
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c osal.c ble_list.c
  group Middlewares/ST/STM32_USBD_Library
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/ST/OPEN.MEMS
    ../../../../../../Middlewares/ST/STM32_OSX_MotionFX_Library/Lib/: osxMotionFX107_CM4_Keil_ot.lib
    ../../../../../../Middlewares/ST/STM32_OSX_MotionAR_Library/Lib/: osxMotionAR120_CM4F_keil_ot.lib
    ../../../../../../Middlewares/ST/STM32_OSX_MotionCP_Library/Lib/: osxMotionCP100_CM4F_Keil_ot.lib
    ../../../../../../Middlewares/ST/STM32_OSX_MotionGR_Library/Lib/: osxMotionGR100_CM4F_Keil_ot.lib
  group Middlewares/ST/STM32_OSX_BlueVoice_Library
    ../../../../../../Middlewares/ST/STM32_OSX_BlueVoice_Library/Lib/: osxBlueVoice200_CM4F_Keil_ot.lib
software components: CMSIS:CORE 5.0.0
