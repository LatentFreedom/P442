# Keil uVision project Project.uvprojx, settings and files
target BlueMS2_STM32F4xx-Nucleo_IKS01A1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BlueMS2_IKS01A1_NucleoF4 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,STM32_NUCLEO,IKS01A1
  c misc: --gnu
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-CCA02M1;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB04A1;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionFX_Library\inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionAR_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionCP_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionGR_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_AcousticSL_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_BlueVoice_Library\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x17fbf
  memory RVCT10: RAM 0x20017fc0 size 0x40
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ./: startup_stm32f401xe.s
  group User
    ../../Src/: AcousticSL_Manager.c AudioBV_Manager.c console.c HWAdvanceFeatures.c main.c MotionAR_Manager.c MotionCP_Manager.c MotionFX_Manager.c MotionGR_Manager.c OTA.c sensor_service.c stm32f4xx_hal_msp.c stm32f4xx_it.c TargetPlatform.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
  group Drivers/BSP/Components/IKS01A1
    ../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
  group Drivers/BSP/Components/IKS01A2
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_UART.c stm32f4xx_nucleo.c stm32f4xx_SPI.c stm32f4xx_I2C.c
  group Drivers/BSP/X-NUCLEO-CCAM02M1
    ../../../../../../Drivers/BSP/X-NUCLEO-CCA02M1/: x_nucleo_cca02m1_audio_f4.c
  group Drivers/BSP/X-NUCLEO-IDB04A1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c
  group Drivers/BSP/X-NUCLEO-IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X-NUCLEO-IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/STM32_BlueNRG
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_utils_small.c bluenrg_gatt_aci.c bluenrg_gap_aci.c bluenrg_l2cap_aci.c bluenrg_hal_aci.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c osal.c ble_list.c
  group Middlewares/STM32_MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group STM32_Audio_PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM4F_Keil.lib
  group Middlewares/ST/OPEN.MEMS
    ../../../../../../Middlewares/ST/STM32_OSX_MotionFX_Library/Lib/: osxMotionFX107_CM4_Keil_ot.lib
    ../../../../../../Middlewares/ST/STM32_OSX_MotionCP_Library/Lib/: osxMotionCP100_CM4F_Keil_ot.lib
    ../../../../../../Middlewares/ST/STM32_OSX_MotionAR_Library/Lib/: osxMotionAR120_CM4F_keil_ot.lib
    ../../../../../../Middlewares/ST/STM32_OSX_MotionGR_Library/Lib/: osxMotionGR100_CM4F_Keil_ot.lib
  group Middlewares/ST/OPEN.AUDIO
    ../../../../../../Middlewares/ST/STM32_OSX_AcousticSL_Library/Lib/: osxAcoustic_SL110_CM4F_Keil_ot.lib
  group Middlewares/ST/STM32_OSX_BlueVoice_Library
    ../../../../../../Middlewares/ST/STM32_OSX_BlueVoice_Library/Lib/: osxBlueVoice200_CM4F_Keil_ot.lib
target BlueMS2_STM32F4xx-Nucleo_IKS01A2 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: as above
  output: BlueMS2_IKS01A2_NucleoF4 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,STM32_NUCLEO,IKS01A2,DISABLE_LSM6DSL_IT,DISABLE_LPS22HB_IT
  c misc: --gnu
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-CCA02M1;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB04A1;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionFX_Library\inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionAR_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionCP_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_MotionGR_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_AcousticSL_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_OSX_BlueVoice_Library\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x17fbf
  memory RVCT10: RAM 0x20017fc0 size 0x40
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.0.0
